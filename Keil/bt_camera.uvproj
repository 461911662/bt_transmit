# Keil uVision project bt_camera.uvproj, settings and files
target Target 1 (MCS-51)
  device: A8107 AMICCOM
  cpu: IRAM(0 - 0xFF) CLOCK(16000000)
  output: bt_camera +hex
  c flags: Optimize=9
  c include: ..\code\include;..\code\BLE Service
  link misc: NOOVERLAY
  group ASM
    ../code/ASM/: startup.a51
    ../code/OTA/: FlashChk.a51 INTERRUPT_OFFSET.asm OTA_IAP.asm
  group BLE_Library
    ../code/Library/: A8107_BLE_LIB.LIB
  group OTA
    ../code/OTA/: OTA.LIB
  group IAP
    ../code/IAP/: IAP.LIB
  group include
    ../code/include/: A8107.h define.h IAP.h LibFunction.h mcufunction.h OTA.h security.h usermcufunction.h
  group BLE_Service
    ../code/BLE Service/: servicegen.c
  group Security_Setting
    ../code/Security Setting/: security.c
  group source
    ../code/source/: application_check.c interrupt.c main_demo.c mcufunction.c usermcufunction.c
  group UserData
    ../code/UserData/: IEEE.a51 OTA_Data.a51
