# Keil uVision project bt_camera.uvproj, settings and files
target Target 1 (MCS-51)
  device: A8107 AMICCOM
  cpu: IRAM(0 - 0xFF) CLOCK(16000000)
  output: bt_camera +hex
  c flags: Optimize=9
  c include: ..\code\include
  link misc: NOOVERLAY
  group source
    ../code/source/: interrupt.c main.c mcufunction.c usermcufunction.c
  group include
    ../code/include/: A8107.h define.h IAP.h io_base.h LibFunction.h mcufunction.h OTA.h servicegen.h usermcufunction.h
  group Library
    ../code/library/: A8107_BLE.LIB
  group blue_service
    ../code/blue_service/: servicegen.c
  group OTA
    ../code/OTA/: OTA.LIB
  group IAP
    ../code/IAP/: IAP.LIB
  group A51
    ../code/ASM/: FlashChk.a51 INTERRUPT_OFFSET.asm OTA_IAP.asm startup.a51
  group user_data
    ../code/user data/: IEEE.a51 OTA_Data.a51
